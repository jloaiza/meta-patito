
PACKAGES += "\
    ${PN}-module-re \
    ${PN}-module-cwd \
    ${PN}-module-text-tabs \
    ${PN}-module-text-wrap \
    ${PN}-module-getopt-std \
    ${PN}-module-file-basename \
"
