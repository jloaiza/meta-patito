
IMAGE_INSTALL_append = "sl cowsay perl"

inherit core-image
